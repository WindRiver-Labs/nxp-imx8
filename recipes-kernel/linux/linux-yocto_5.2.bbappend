require linux-yocto-nxp-imx8.inc

KBRANCH_nxp-imx8 = "v5.2/standard/nxp-imx/sdk-4.19.35/nxp-imx8"
