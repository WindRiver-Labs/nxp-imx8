require linux-yocto-nxp-imx8.inc

KBRANCH_nxp-imx8 = "standard/nxp-imx/sdk-4.9.88/nxp-imx8"
