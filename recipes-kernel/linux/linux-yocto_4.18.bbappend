require linux-yocto-nxp-imx8.inc

KBRANCH_nxp-imx8 = "v4.18/standard/nxp-imx/sdk-4.14.78/nxp-imx8"
