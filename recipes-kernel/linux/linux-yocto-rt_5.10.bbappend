require linux-yocto-nxp-imx8.inc

KBRANCH_nxp-imx8  = "v5.10/standard/preempt-rt/nxp-sdk-5.10/nxp-soc"

LINUX_VERSION_nxp-imx8 ?= "5.10.x"
