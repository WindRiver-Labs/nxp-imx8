require linux-yocto-nxp-imx8.inc

KBRANCH_nxp-imx8  = "v5.4/standard/nxp-imx8"

LINUX_VERSION_nxp-imx8 ?= "5.4.x"
